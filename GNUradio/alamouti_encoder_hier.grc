options:
  parameters:
    generate_options: hb
    id: alamouti_encoder
    output_language: python
    title: Alamouti Encoder
  states: {}

blocks:
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: complex
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    type: complex
  states: {}
- name: blocks_streams_to_stream_0
  id: blocks_streams_to_stream
  parameters:
    type: complex
  states: {}
- name: blocks_streams_to_stream_0_0
  id: blocks_streams_to_stream
  parameters:
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    num_streams: '2'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '0'
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_conjugate_cc_0_0, '0', blocks_streams_to_stream_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_streams_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_streams_to_stream_0, '1']
- [blocks_stream_to_streams_0, '0', blocks_conjugate_cc_0_0, '0']
- [blocks_stream_to_streams_0, '0', blocks_streams_to_stream_0, '0']
- [blocks_stream_to_streams_0, '1', blocks_conjugate_cc_0, '0']
- [blocks_stream_to_streams_0, '1', blocks_streams_to_stream_0_0, '0']
- [blocks_streams_to_stream_0, '0', pad_sink_0, '0']
- [blocks_streams_to_stream_0_0, '0', pad_sink_0, '1']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
