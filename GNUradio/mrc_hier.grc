options:
  parameters:
    generate_options: hb
    id: mrc_hier
    output_language: python
    title: Maximum Ratio Combiner
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: '64'
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: '64'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '64'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '64'
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_1
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
    vlen: '64'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    vlen: '64'
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters:
    vlen: '64'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: '64'
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: '64'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
    vlen: '64'
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: R1
    type: complex
    vlen: '64'
  states: {}
- name: pad_source_1_0
  id: pad_source
  parameters:
    label: R2
    type: complex
    vlen: '64'
  states: {}
- name: pad_source_1_1
  id: pad_source
  parameters:
    label: h_1
    type: complex
    vlen: '64'
  states: {}
- name: pad_source_1_2
  id: pad_source
  parameters:
    label: h_2
    type: complex
    vlen: '64'
  states: {}

connections:
- [blocks_add_xx_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_add_xx_0_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_conjugate_cc_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_conjugate_cc_0_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_divide_xx_0, '0', pad_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_stream_to_vector_0, '0', blocks_multiply_xx_0, '1']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_conjugate_cc_0_1, '0']
- [pad_source_1, '0', blocks_multiply_xx_0, '0']
- [pad_source_1_0, '0', blocks_multiply_xx_0_0, '0']
- [pad_source_1_1, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_1_1, '0', blocks_vector_to_stream_0, '0']
- [pad_source_1_2, '0', blocks_complex_to_mag_squared_0_0, '0']
- [pad_source_1_2, '0', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
